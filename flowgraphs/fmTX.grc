<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fmTX</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_samp_in</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>die__</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>GUI Kill</value></param>
<param><key>pressed</key><value>1</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>103.7e6</value></param>
<param><key>label</key><value>Frequency Slider</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>88e6</value></param>
<param><key>step</key><value>100e3</value></param>
<param><key>stop</key><value>108e6</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>ptt</value></param>
<param><key>value</key><value>0</value></param>
<param><key>pressed</key><value>1</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>comment</key><value>hackRF: 1.03M</value></param>
<param><key>value</key><value>1.323e6</value></param>
<param><key>label</key><value>Sample Rate Slider</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>6.00e6</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>swap__</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Switch to RX</value></param>
<param><key>pressed</key><value>1</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>analog_wfm_tx</key>
<param><key>id</key><value>analog_wfm_tx_0</value></param>
<param><key>audio_rate</key><value>audio_samp_in</value></param>
<param><key>max_dev</key><value>75e3</value></param>
<param><key>quad_rate</key><value>audio_samp_in * 3</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>samp_rate</key><value>44100</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>ptt</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>if_gain0</key><value>47</value></param>
<param><key>gain0</key><value>14</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>10</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>analog_wfm_tx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>analog_wfm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
